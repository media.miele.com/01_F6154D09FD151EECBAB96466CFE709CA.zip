Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-06-08T08:34:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 08 08:34:54 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\94967f53-a784-476b-97b2-aa814e67673a\07c78f48-647e-41c5-b1d4-e4ef3ba52cd3\ifc * Database version: 5507 * Database creation date: Wed Jun 08 08:34:53 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 08 08:34:53 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 08 08:34:53 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11755650_BR_CVA7845_GRGR:29784530_BR_11755650_CVA7845_GRGR, (2)
In: Default
Type - Material: z_Miele_Design_Glass, z_Miele_Design_CLST, z_Miele_Design_GRGR, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black
Type - Pset_BuildingElementProxyCommon - Reference: 29784530_BR_11755650_CVA7845_GRGR
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 29784530_BR_11755650_CVA7845_GRGR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 455 mm; Depth: 475 mm

# IfcDistributionPort, Port_353128
Description: Flow; FlowDirection: SOURCEANDSINK
